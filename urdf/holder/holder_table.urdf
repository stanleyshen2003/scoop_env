Commit message: new tasks

File: urdf/holder/holder_table.urdf (robot description, URDF)
Before this commit: robot holder, 1 links, 0 joints
Links:
- link holder: geometry collision box size=0.8 2 0.9; collision mesh filename=holder.obj
