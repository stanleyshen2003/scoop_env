Commit message: add tofu

File: urdf/container/bowl_tofu.urdf (robot description, URDF)
Before this commit: robot bowl, 2 links, 1 joints
Links:
- link tofu: mass None -> 0.00001
