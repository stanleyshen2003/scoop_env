Commit message: add 0114

File: urdf/grab_tool/spoon.urdf (robot description, URDF)
Before this commit: robot spoon, 2 links, 1 joints
Links:
- link cube_spoon: mass 0.1 -> 0.01
- link spoon: mass 0.05 -> 0.01
